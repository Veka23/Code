# IAR project iarproject.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: Rtos; Rtos\wrapper; Rtos\wrapper\FreeRtos; Rtos\FreeRtos; Rtos\FreeRtos\include; Rtos\FreeRtos\portable; Rtos\FreeRtos\portable\Common; Rtos\FreeRtos\portable\IAR; Rtos\FreeRtos\portable\IAR\ARM_CM4F; Rtos\FreeRtos\portable\MemMang; Common; CMSIS; Application; Application\Diagnostic; AHardware; AHardware\GpioPort; AHardware\IrqController; ..\CortexLib-master\AbstractHardware\Pin; ..\CortexLib-master\AbstractHardware\Registers\STM32F411\FieldValues; ..\CortexLib-master\AbstractHardware\Registers\STM32F411; ..\CortexLib-master\AbstractHardware\Registers; ..\CortexLib-master\AbstractHardware\Port; ..\CortexLib-master\AbstractHardware\Atomic; ..\CortexLib-master\Common; ..\CortexLib-master\Common\Singleton; AHardware\Registers; AHardware\Registers\CortexM4; AHardware\Registers\CortexM4\FieldValues; AHardware\Registers\STM32F411; AHardware\Registers\STM32F411\FieldValues; AHardware\Timer; $PROJ_DIR$; AHardware\LedTask; Application\Filter; Application\VariableTask; Application\Voltage; Application\Ivariable; AHardware\ADC; AHardware\DMA; AHardware\PWM; AHardware\IrqController; AHardware\USART2; AHardware\Led; AHardware\USART2; AHardware\UsartDriver; Application\BlueToothTask
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: Rtos; Rtos\FreeRtos; Rtos\FreeRtos\include; Rtos\FreeRtos\portable\IAR; Rtos\FreeRtos\portable\IAR\ARM_CM4F; Rtos\wrapper\FreeRtos; Rtos\wrapper
  OBJCOPY.OOCOutputFile: iarproject.srec
  ILINK.IlinkOutputFile: iarproject.out
  ILINK.IlinkIcfFile: stm32f411xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ./: main.cpp startupF411RE.cpp
    CortexLib-master/Common/: susudefs.hpp
  group AHardware/ADC
    AHardware/ADC/: ADC.hpp
  group AHardware/DMA
    AHardware/DMA/: DMA.hpp
  group AHardware/IrqController
    AHardware/IrqController/: irqcontroller.cpp irqcontroller.hpp
  group AHardware/ITransmit
    AHardware/ITransmit/: ITransmit.h
  group AHardware/Led
    AHardware/Led/: Led.hpp
  group AHardware/LedTask
    AHardware/LedTask/: LedTask.hpp
  group AHardware/PWM
    AHardware/PWM/: PWM.hpp
  group AHardware/Registers
    AHardware/Registers/: accessmode.hpp fieldvalue.hpp fieldvaluebase.hpp register.hpp registerbase.hpp registerfield.hpp registertype.hpp
  group AHardware/Registers/CortexM4
    AHardware/Registers/CortexM4/: fpucpacrregisters.hpp fpuregisters.hpp mpuregisters.hpp nvicregisters.hpp nvicstirregisters.hpp scbactrlregisters.hpp scbregisters.hpp stkregisters.hpp
  group AHardware/Registers/CortexM4/FieldValues
    AHardware/Registers/CortexM4/FieldValues/: fpucpacrfieldvalues.hpp fpufieldvalues.hpp mpufieldvalues.hpp nvicfieldvalues.hpp nvicstirfieldvalues.hpp scbactrlfieldvalues.hpp scbfieldvalues.hpp stkfieldvalues.hpp
  group AHardware/Registers/STM32F411
    AHardware/Registers/STM32F411/: adc1registers.hpp adccommonregisters.hpp crcregisters.hpp dbgregisters.hpp dma1registers.hpp dma2registers.hpp extiregisters.hpp flashregisters.hpp gpioaregisters.hpp gpiobregisters.hpp gpiocregisters.hpp gpiodregisters.hpp gpioeregisters.hpp gpiohregisters.hpp i2c1registers.hpp i2c2registers.hpp i2c3registers.hpp i2s2extregisters.hpp i2s3extregisters.hpp iwdgregisters.hpp otgfsdeviceregisters.hpp otgfsglobalregisters.hpp otgfshostregisters.hpp otgfspwrclkregisters.hpp portslist.hpp pwrregisters.hpp rccregisters.hpp rtcregisters.hpp sdioregisters.hpp spi1registers.hpp spi2registers.hpp spi3registers.hpp spi4registers.hpp spi5registers.hpp syscfgregisters.hpp tim10registers.hpp tim11registers.hpp tim1registers.hpp tim2registers.hpp tim3registers.hpp tim4registers.hpp tim5registers.hpp tim8registers.hpp tim9registers.hpp usart1registers.hpp usart2registers.hpp usart6registers.hpp wwdgregisters.hpp
  group AHardware/Registers/STM32F411/FieldValues
    AHardware/Registers/STM32F411/FieldValues/: adc1fieldvalues.hpp adccommonfieldvalues.hpp crcfieldvalues.hpp dbgfieldvalues.hpp dma1fieldvalues.hpp dma2fieldvalues.hpp extifieldvalues.hpp flashfieldvalues.hpp gpioafieldvalues.hpp gpiobfieldvalues.hpp gpiocfieldvalues.hpp gpiodfieldvalues.hpp gpioefieldvalues.hpp gpiohfieldvalues.hpp i2c1fieldvalues.hpp i2c2fieldvalues.hpp i2c3fieldvalues.hpp i2s2extfieldvalues.hpp i2s3extfieldvalues.hpp iwdgfieldvalues.hpp otgfsdevicefieldvalues.hpp otgfsglobalfieldvalues.hpp otgfshostfieldvalues.hpp otgfspwrclkfieldvalues.hpp pwrfieldvalues.hpp rccfieldvalues.hpp rtcfieldvalues.hpp sdiofieldvalues.hpp spi1fieldvalues.hpp spi2fieldvalues.hpp spi3fieldvalues.hpp spi4fieldvalues.hpp spi5fieldvalues.hpp syscfgfieldvalues.hpp tim10fieldvalues.hpp tim11fieldvalues.hpp tim1fieldvalues.hpp tim2fieldvalues.hpp tim3fieldvalues.hpp tim4fieldvalues.hpp tim5fieldvalues.hpp tim8fieldvalues.hpp tim9fieldvalues.hpp usart1fieldvalues.hpp usart2fieldvalues.hpp usart6fieldvalues.hpp wwdgfieldvalues.hpp
  group AHardware/USART2
    AHardware/USART2/: Usart.hpp usartconfig.hpp
  group AHardware/UsartDriver
    AHardware/UsartDriver/: usartdriver.hpp
  group Application/BlueToothTask
    Application/BlueToothTask/: BlueToothTask.hpp
  group Application/Filter
    Application/Filter/: Filter.hpp
  group Application/Ivariable
    Application/Ivariable/: IVariable.hpp
  group Application/VariableTask
    Application/VariableTask/: VariableTask.hpp
  group Application/Voltage
    Application/Voltage/: Voltage.hpp
  group Rtos/FreeRtos
    Rtos/FreeRtos/: croutine.c event_groups.c FreeRTOSConfig.h list.c queue.c tasks.c timers.c
  group Rtos/FreeRtos/include
    Rtos/FreeRtos/include/: croutine.h deprecated_definitions.h desktop.ini event_groups.h FreeRTOS.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h stdint.readme task.h timers.h
  group Rtos/FreeRtos/portable/Common
    Rtos/FreeRtos/portable/Common/: mpu_wrappers.c
  group Rtos/FreeRtos/portable/IAR/ARM_CM4F
    Rtos/FreeRtos/portable/IAR/ARM_CM4F/: port.c portasm.c portasm.s portasm.xcl portmacro.h
  group Rtos/FreeRtos/portable/MemMang
    Rtos/FreeRtos/portable/MemMang/: heap_1.c ReadMe.url
  group Rtos/wrapper
    Rtos/wrapper/: criticalsection.hpp event.hpp eventmode.hpp interruptentry.hpp mailbox.hpp mutex.hpp rtos.hpp thread.hpp
  group Rtos/wrapper/FreeRtos
    Rtos/wrapper/FreeRtos/: rtosdefs.hpp rtoswrapper.hpp
